Commit message: Correct urdf example

File: examples/10_Sensordatenhandling/urdf_example/example.urdf (robot description, URDF)
Before this commit: robot origins, 2 links, 1 joints
Joints:
- joint base_to_right_leg: type fixed -> continuous
